# Keil uVision project project.uvprojx, settings and files
target rt-thread (6220000::V6.22::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: keil-build-viewer.exe -NOPATH
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: printf=rt_kprintf, snprintf=rt_snprintf, __RTTHREAD__, LFS_CONFIG=lfs_config.h, USE_HAL_DRIVER, RT_USING_LIBC, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, sprintf=rt_sprintf, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-pointer-bool-conversion -Wno-tautological-pointer-compare -Wno-invalid-source-encoding -Wno-logical-not-parentheses
  c include: ..\Libraries\rt-thread\libcpu\arm\cortex-m7;..\Libraries\ThirdParty\littlefs;..\Libraries\rt-thread\components\dfs\dfs_v1\filesystems\romfs;..\Libraries\ThirdParty\rt-thread-syswatch\inc;..\BSP\Drivers;..\Libraries\rt-thread\components\drivers\usb\cherryusb\class\video;..\Libraries\rt-thread\components\drivers\usb\cherryusb\class\msc;..\Libraries\rt-thread\components\drivers\usb\cherryusb\osal;.;..\BSP\Board\CubeMX_Config\Core\Inc;..\Libraries\rt-thread\components\drivers\usb\cherryusb\class\vendor\serial;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\bsp\stm32\libraries\HAL_Drivers;..\Libraries\Vendor\STM32\stm32h7xx_hal_driver\Inc;..\Libraries\ThirdParty\cmsis_core\Include;..\UserSrc\Applications;..\Libraries\Vendor\STM32\cmsis_device_h7\Include;..\Libraries\rt-thread\components\dfs\dfs_v1\filesystems\elmfat;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\libc\posix\io\poll;..\Libraries\rt-thread\components\libc\compilers\common\extension;..\Libraries\rt-thread\libcpu\arm\common;..\Libraries\rt-thread\components\drivers\spi;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\Libraries\rt-thread\components\libc\compilers\common\include;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\drivers\usb\cherryusb\class\audio;..\Libraries\rt-thread\components\utilities\ulog\backend;..\BSP\Drivers;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\libc\posix\io\eventfd;..\BSP\Board;..\Libraries\rt-thread\components\dfs\dfs_v1\filesystems\devfs;..\Libraries\rt-thread\components\drivers\usb\cherryusb\core;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\libc\posix\io\epoll;..\Libraries\ThirdParty\CmBacktrace;..\Libraries\rt-thread\components\fal\inc;..\BSP\Storage;..\Libraries\rt-thread\components\drivers\usb\cherryusb\class\wireless;..\Libraries\rt-thread\include;..\Libraries\rt-thread\bsp\stm32\libraries\HAL_Drivers\drivers\config;..\UserSrc\Drivers;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\drivers\usb\cherryusb\class\midi;..\Libraries\rt-thread\components\drivers\spi\sfud\inc;..\Libraries\rt-thread\bsp\stm32\libraries\HAL_Drivers\drivers;..\Libraries\rt-thread\components\libc\posix\ipc;..\Libraries\rt-thread\components\utilities\ulog;..\Libraries\rt-thread\bsp\stm32\libraries\HAL_Drivers\CMSIS\Include;..\Libraries\rt-thread\components\drivers\usb\cherryusb\common;..\Libraries\ThirdParty\MFBD;..\Libraries\rt-thread\components\drivers\include;..\Libraries\rt-thread\components\drivers\usb\cherryusb\class\vendor\net;..\Libraries\rt-thread\components\finsh;..\Libraries\rt-thread\components\dfs\dfs_v1\include;..\Libraries\rt-thread\components\drivers\usb\cherryusb\class\dfu;..\Libraries\rt-thread\components\drivers\usb\cherryusb\class\hid;..\Libraries\rt-thread\components\drivers\usb\cherryusb\class\cdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\..\BSP\Board\linker_scripts\STM32H750XBHx\link.sct
  group Applications
    ../UserSrc/Applications/: user_led.c bsp_key.c
  group ..\BSP\Board
    ../BSP/Board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c mdma.c stm32h7xx_it.c dma.c sdmmc.c gpio.c fmc.c system_stm32h7xx.c rtc.c iwdg.c quadspi.c main.c spi.c ltdc.c dma2d.c usb_otg.c memorymap.c usart.c
    ../BSP/Board/../BSP/: Board.c
  group Local Sources
    ../BSP/Drivers/: drv_led.c drv_mpu.c
    ../BSP/Storage/: filesystem.c spi_flash_init.c ulog_file_be.c
    ../UserSrc/Drivers/: sensor_sht3x.c sht3x.c user_adc.c user_alarm.c user_pm.c user_uart1.c
  group CherryUSB
    ../Libraries/rt-thread/components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
    ../Libraries/rt-thread/components/drivers/usb/cherryusb/port/dwc2/: usb_glue_st.c usb_dc_dwc2.c
    ../Libraries/rt-thread/components/drivers/usb/cherryusb/demo/: cdc_acm_msc_template.c
    ../Libraries/rt-thread/components/drivers/usb/cherryusb/platform/rtthread/: usb_check.c usb_msh.c
    ../Libraries/rt-thread/components/drivers/usb/cherryusb/class/cdc/: usbd_cdc.c
    ../Libraries/rt-thread/components/drivers/usb/cherryusb/class/msc/: usbd_msc.c
    ../Libraries/rt-thread/components/drivers/usb/cherryusb/core/: usbd_core.c
  group cm_backtrace
    ../Libraries/ThirdParty/CmBacktrace/: cmb_flash_log.c cm_backtrace.c cmb_port.c
  group Compiler
    ../Libraries/rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../Libraries/rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../Libraries/rt-thread/components/drivers/core/: device.c
    ../Libraries/rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../Libraries/rt-thread/components/drivers/mtd/: mtd_nor.c
    ../Libraries/rt-thread/components/drivers/pin/: pin.c
    ../Libraries/rt-thread/components/drivers/rtc/: rtc.c
    ../Libraries/rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    ../Libraries/rt-thread/components/drivers/serial/: serial_v2.c
    ../Libraries/rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../Libraries/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../Libraries/rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    ../Libraries/rt-thread/bsp/stm32/libraries/HAL_Drivers/drivers/: drv_gpio.c drv_lcd.c drv_rtc.c drv_sdmmc.c drv_sdram.c drv_spi.c drv_usart_v2.c drv_wdt.c
    ../Libraries/rt-thread/bsp/stm32/libraries/HAL_Drivers/: drv_common.c
  group Fal
    ../Libraries/rt-thread/components/fal/src/: fal_partition.c fal_rtt.c fal_flash.c fal.c
    ../Libraries/rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../Libraries/rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../Libraries/rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../Libraries/rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    ../Libraries/rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../Libraries/rt-thread/components/finsh/: msh_file.c cmd.c msh_parse.c msh.c shell.c
  group Kernel
    ../Libraries/ThirdParty/rt_memcpy_cm/: rt_memcpy_rvds.S
    ../Libraries/rt-thread/src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c memheap.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../Libraries/rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    ../Libraries/rt-thread/libcpu/arm/common/: div0.c showmem.c
    ../Libraries/rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group littlefs
    ../Libraries/ThirdParty/littlefs/: lfs_util.c lfs_crc.c dfs_lfs.c lfs.c
  group mfbd
    ../Libraries/ThirdParty/MFBD/: mfbd.c
  group STM32_HAL
    ../Libraries/Vendor/STM32/stm32h7xx_hal_driver/Src/: stm32h7xx_hal_sram.c stm32h7xx_hal_hcd.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_uart.c stm32h7xx_hal_qspi.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_rtc.c stm32h7xx_hal_dma.c stm32h7xx_hal_cortex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_nor.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_pwr.c stm32h7xx_hal_mdma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_comp.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_usb.c stm32h7xx_hal_dma2d.c stm32h7xx_hal.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_crc.c stm32h7xx_hal_dma_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_usart.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_rng.c stm32h7xx_hal_spi.c
    ../Libraries/Vendor/STM32/cmsis_device_h7/Source/Templates/arm/: startup_stm32h750xx.s
  group syswatch
    ../Libraries/ThirdParty/rt-thread-syswatch/src/: syswatch.c syswatch_test.c
  group Utilities
    ../Libraries/rt-thread/components/utilities/ulog/backend/: file_be.c console_be.c
    ../Libraries/rt-thread/components/utilities/ulog/: ulog.c
