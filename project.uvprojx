# Keil uVision project project.uvprojx, settings and files
target rt-thread (6190000::V6.19::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: __STDC_LIMIT_MACROS, LFS_CONFIG=lfs_config.h, sprintf=rt_sprintf, USE_HAL_DRIVER, RT_USING_LIBC, printf=rt_kprintf, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARMLIBC, snprintf=rt_snprintf
  c misc: -Wno-pointer-bool-conversion -Wno-tautological-pointer-compare -Wno-invalid-source-encoding -Wno-logical-not-parentheses
  c include: rt-thread\components\libc\compilers\common\extension\fcntl\octal;libraries\samples;libraries\HAL_Drivers\CMSIS\Include;.;rt-thread\components\drivers\include;board\port;rt-thread\components\fal\inc;rt-thread\include;rt-thread\components\drivers\include;rt-thread\components\dfs\include;rt-thread\components\utilities\ymodem;rt-thread\components\libc\posix\io\poll;packages\get_irq_priority-latest;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\libc\compilers\common\include;BoardDriver\file;rt-thread\components\drivers\spi\sfud\inc;libraries\HAL_Drivers;packages\MFBD-latest;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\utilities\ulog\backend;rt-thread\components\utilities\ulog;packages\littlefs-latest;rt-thread\components\finsh;rt-thread\libcpu\arm\common;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\libc\posix\io\stdio;rt-thread\components\drivers\include;packages\syswatch-latest\inc;BoardDriver\user;rt-thread\components\utilities\libadt;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\libc\posix\ipc;rt-thread\components\dfs\filesystems\devfs;board\CubeMX_Config\Core\Inc;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\drivers\include;libraries\HAL_Drivers\config;packages\CmBacktrace-latest;BoardDriver\drivers;board;rt-thread\components\libc\compilers\common\extension;applications;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group ADT
    rt-thread/components/utilities/libadt/: avl.c
  group Applications
    applications/: user_led.c bsp_key.c
  group board
    board/: board.c
    board/CubeMX_Config/Core/Src/: main.c stm32h7xx_it.c adc.c dma.c usart.c iwdg.c stm32h7xx_hal_msp.c spi.c quadspi.c system_stm32h7xx.c sdmmc.c gpio.c rtc.c
  group BoardDriver
    BoardDriver/drivers/: drv_led.c drv_mpu.c
    BoardDriver/file/: filesystem.c spi_flash_init.c ulog_file_be.c
    BoardDriver/user/: user_adc.c user_uart1.c
  group cm_backtrace
    packages/CmBacktrace-latest/: cmb_port.c cm_backtrace.c cmb_flash_log.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    libraries/HAL_Drivers/: drv_gpio.c drv_spi.c drv_usart_v2.c drv_wdt.c drv_sdio.c drv_rtc.c drv_common.c
  group Fal
    rt-thread/components/fal/src/: fal_rtt.c fal_partition.c fal_flash.c fal.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group get_irq_priority
    packages/get_irq_priority-latest/src/: get_irq.c
  group Kernel
    packages/rt_memcpy_cm-latest/: rt_memcpy_rvds.S
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group littlefs
    packages/littlefs-latest/: lfs.c lfs_util.c dfs_lfs.c lfs_crc.c
  group mfbd
    packages/MFBD-latest/: mfbd.c
  group rt_kprintf
    packages/rt_kprintf_threadsafe-latest/: rt_kprintf.c
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_sram.c stm32h7xx_hal_rtc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_nor.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group syswatch
    packages/syswatch-latest/src/: syswatch.c syswatch_test.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c file_be.c
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ymodem/: ry_sy.c ymodem.c
